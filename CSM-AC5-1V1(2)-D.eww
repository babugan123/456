<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CSM-AC5-1V1(2)-D.ewp</path>
  </project>
  <batchBuild/>
</workspace>


